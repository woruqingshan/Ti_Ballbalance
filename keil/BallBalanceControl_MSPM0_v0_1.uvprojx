# Keil uVision project BallBalanceControl_MSPM0_v0_1.uvprojx, settings and files
target BallBalanceControl_MSPM0_v0_1 (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BallBalanceControl_MSPM0_v0_1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c misc: -ffunction-sections -fdata-sections
  c include: ../src;../generated;D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\source\third_party\CMSIS\Core\Include;D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\source
  scatter file: ./mspm0g3507.sct
  link misc: D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group App
    ../src/app/: app_main.c
  group BSP
    ../src/bsp/: bsp_time.c
  group Communication
    ../src/communication/: uart_ring.c vision_uart.c vision_link.c
  group Protocol
    ../src/protocol/: crc16.c protocol.c
  group Control
    ../src/control/: ball_controller.c
  group Motor
    ../src/motor/: emm_v5_driver.c motor_position.c motor_scheduler.c rod_motor_mapper.c emm_v5_protocol.c
  group Task
    ../src/task/: task3.c
  group Safety
    ../src/safety/: safety.c
  group Vehicle
    ../src/vehicle/: vehicle_stub.c
  group Telemetry
    ../src/telemetry/: telemetry.c
  group Generated
    ../generated/: ti_msp_dl_config.c
  group Startup
    D:/TI/M0_SDK/mspm0_sdk_2_02_00_05/source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group TestModes
    ../src/test_modes/: test_console.c emm_position_calibration_test.c motor_sign_test.c
